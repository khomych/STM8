<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BoilerAirControll.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\LEARNING\Servo\Servo.ewp</path>
    </project>
    <batchBuild />
</workspace>
