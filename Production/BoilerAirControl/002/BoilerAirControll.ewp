# IAR project BoilerAirControll.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; HSE_VALUE=((uint32_t)16000000); HSI_VALUE=((uint32_t)16000000); LSI_VALUE=((uint32_t)128000); LsiFreq=((uint32_t)128000)
  ICCSTM8.CCIncludePath2: inc; lib\SPL\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: SPL_STM8S_template.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    inc/: function.h lib_1wire.h lib_ds18b20.h lib_max7219.h lib_pwm.h main.h stm8s_conf.h stm8s_it.h
  group lib/SPL/inc
    lib/SPL/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group lib/SPL/src
    lib/SPL/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group src
    src/: function.c lib_1wire.c lib_ds18b20.c lib_max7219.c lib_pwm.c main.c stm8s_it.c
